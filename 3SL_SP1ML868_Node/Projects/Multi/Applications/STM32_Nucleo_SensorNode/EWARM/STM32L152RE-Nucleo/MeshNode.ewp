# IAR project MeshNode.ewp, settings and files
configuration STM32L152RE-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151VB ST STM32L151VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; USE_STM32L1XX_NUCLEO; USE_HAL_DRIVER; UIP_CONF_IPV6=1; UIP_CONF_IPV6_RPL=1; CONTIKI=1; WITH_UIP6=1; IAR=1; USE_STDPERIPH_DRIVER; IAR_ARM_CM3; NO_EEPROM; USE_SPIRIT1_DEFAULT; NETSTACK_CONF_WITH_IPV6; NETSTACK_CONF_WITH_RIME; SPIRIT1_868; MESH_NODE_SP1ML; LED_FEATURE; UIP_CONF_TCP=1; X_NUCLEO_IDS01A4; AUTOSTART_ENABLE; LED_FEATURE; NODE_3SL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes\; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB04A1; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IKS01A1; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev\; ..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc\; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\; ..\..\..\..\..\..\Drivers\BSP\Components\hts221\; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3\; ..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl\; ..\..\..\..\..\..\Drivers\BSP\Components\lps25h\; ..\..\..\..\..\..\Drivers\BSP\Components\lps25hb\; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0\; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\dev; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\loader\; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\mac\contikimac; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\mac\sicslowmac; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\mac\cxmac; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip64; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki\cpu\arm\stm32; ..\..\..\..\..\..\Middlewares\Third_Party\Contiki; ..\..\..\..\..\..\Projects\Multi\Applications\SPIRIT_MEMS_MeshNode_App\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L152RE-Nucleo_SensorNode.bin
  ILINK.IlinkOutputFile: MeshNode.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/SENSORS
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
  group Drivers/BSP/SPIRIT1
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/STM32L1xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/X-NUCLEO-IKS01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32l152xe.s
  group Example/User
    ../../Src/: contiki-spirit1-main.c cube_hal_l1.c main.c mesh-node.c sensor_node.c servreg-hack.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Middlewares/Contiki
    ../../../../../../Middlewares/Third_Party/Contiki/examples/ipv6/rpl-border-router/: border-router.c httpd-simple.c slip-bridge.c
  group Middlewares/Contiki/core/dev
    ../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c nullradio.c serial-line.c slip.c
  group Middlewares/Contiki/core/lib
    ../../../../../../Middlewares/Third_Party/Contiki/core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c trickle-timer.c
  group Middlewares/Contiki/core/loader
    ../../../../../../Middlewares/Third_Party/Contiki/core/loader/: elfloader.c
  group Middlewares/Contiki/core/net
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/: linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: dhcpc.c ip64-addr.c psock.c resolv.c simple-udp.c slipdev.c tcp-socket.c tcpip.c udp-socket.c uip-debug.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group Middlewares/Contiki/core/net/ip64
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ip64/: ip64-addrmap.c ip64-arp.c ip64-dhcpc.c ip64-eth-interface.c ip64-eth.c ip64-ipv4-dhcp.c ip64-null-driver.c ip64-slip-interface.c ip64-special-ports.c
  group Middlewares/Contiki/core/net/ipv4
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv4/: uaodv-rt.c uaodv.c uip-fw-drv.c uip-fw.c uip-neighbor.c uip-over-mesh.c uip.c uip_arp.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group Middlewares/Contiki/core/net/ipv6/multicast
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: csma.c frame802154.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c
  group Middlewares/Contiki/core/net/mac/contikimac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/contikimac/: contikimac-framer.c contikimac.c
  group Middlewares/Contiki/core/net/mac/cxmac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/cxmac/: cxmac.c
  group Middlewares/Contiki/core/net/mac/sicslowmac
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/sicslowmac/: sicslowmac.c
  group Middlewares/Contiki/core/net/rime
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/rime/: abc.c announcement.c broadcast-announcement.c broadcast.c chameleon-bitopt.c chameleon-raw.c chameleon.c channel.c collect-link-estimate.c collect-neighbor.c collect.c ipolite.c mesh.c multihop.c neighbor-discovery.c netflood.c packetqueue.c polite-announcement.c polite.c rime.c rimestats.c rmh.c route-discovery.c route.c rucb.c rudolph1.c rudolph2.c runicast.c stbroadcast.c stunicast.c timesynch.c trickle.c unicast.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c
  group Middlewares/Contiki/core/sys
    ../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group Middlewares/Contiki_STM32_Library
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: button-sensor.c leds-arch.c
    ../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: clock.c contiki-spirit1-main.c node-id.c rtimer-arch.c spirit1-arch.c spirit1.c uart-msg.c watchdog.c
