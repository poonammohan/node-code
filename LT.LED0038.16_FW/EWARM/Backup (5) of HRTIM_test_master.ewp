# IAR project Backup (5) of HRTIM_test_master.ewp, settings and files
configuration HRTIM_test_master (ARM, debug)
  General.OGChipSelectEditMenu: STM32F334R8 ST STM32F334R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F334x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HRTIM_test_master.bin
  ILINK.IlinkOutputFile: HRTIM_test_master.out
  ILINK.IlinkIcfFile: stm32f334x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f334x8.s
  group Application/User
    ../Src/: ac_dc_ld.c battery.c buzzer.c connectivity.c dc_dc_ld.c led.c main.c mppt.c panel.c state.c stm32f3xx_hal_msp.c stm32f3xx_it.c system.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_wwdg.c
    ../Drivers/stm32f3xx_hal_driver/Src/: stm32f3xx_hal_adc_ex.c
